# IAR project io.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../components/common; ../../components/targets/zigbee-mcu1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0\8051\config\devices\Texas Instruments\lnk51ew_cc2530b.xcl
  group application
    ./: io.c
  group common
    ../../components/common/: hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h
  group targets
    ../../components/targets/zigbee-mcu1/: hal_board.c hal_board.h hal_button.c hal_button.h hal_buzzer.c hal_buzzer.h hal_led.c hal_led.h
