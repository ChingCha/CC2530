# IAR project switch.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../components/common; ../../components/basicrf; ../../components/utils; ../../components/targets/zigbee-mcu1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0_2\8051\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group application
    ./: switch.c
  group basicrf
    ../../components/basicrf/: basic_rf.c basic_rf_security.c
  group common
    ../../components/common/: hal_clock.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c
  group targets
    ../../components/targets/zigbee-mcu1/: hal_board.c hal_button.c hal_buzzer.c hal_keypad.c hal_led.c hal_uart.c
    ../../components/common/: hal_lcd.c
  group utils
    ../../components/utils/: util.c util_buffer.c
