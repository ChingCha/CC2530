<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_basic\basic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_keypad_lcd\keypad_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_light_switch\light_switch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M100\M100.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M110\M110.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M120\M120.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M130\M130.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M140\M140.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M150\M150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M160\M160.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M170\M170.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M180\M180.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M190\M190.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M200\M200.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M210\M210.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M220\M220.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M230\M230.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M240\M240.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M250\M250.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M260\M260.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M270\M270.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M280\M280.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M290\M290.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_M320\M320.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit1\ex_uart\uart.ewp</path>
  </project>
  <batchBuild/>
</workspace>


