<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zigbee-mcu1\ex_io\io.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\zigbee-mcu1\ex_light\light.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\zigbee-mcu1\ex_switch\switch.ewp</path>
  </project>
  <batchBuild/>
</workspace>


