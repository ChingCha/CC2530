# IAR project basic.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../components/basicrf; ../../components/common; ../../components/targets/mcu-net1; ../../components/utils; ../../components/module
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk51ew_cc2530b.xcl
  group application
    ./: ex.c
    ../../components/module/: M180.c M180.h M190.c M190.h M240.c M240.h
  group basicrf
    ../../components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group common
    ../../components/common/: hal_adc.c hal_adc.h hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_digio.c hal_digio.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_types.h
  group targets
    ../../components/targets/mcu-net1/: hal_board.c hal_board.h hal_buzzer.c hal_buzzer.h hal_relay.c hal_relay.h hal_rtc.c hal_rtc.h hal_uart.c hal_uart.h
  group utils
    ../../components/utils/: util.c util.h util_buffer.c util_buffer.h
