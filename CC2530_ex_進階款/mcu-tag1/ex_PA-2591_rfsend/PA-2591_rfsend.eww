<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PA-2591_rfsend.ewp</path>
  </project>
  <batchBuild/>
</workspace>


