# IAR project basic.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../components/utils; ../../components/common; ../../components/basicrf; ../../components/module; ../../components/targets/mcu-kit1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0\8051\config\devices\Texas Instruments\lnk51ew_cc2530b.xcl
  group application
    ./: basic.c
  group basic rf
    ../../components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group common
    ../../components/common/: hal_adc.c hal_adc.h hal_cc8051.h hal_clock.c hal_clock.h hal_defs.h hal_digio.c hal_digio.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_rf_util.c hal_rf_util.h
  group module
    ../../components/module/: M140.c M140.h M160.c M160.h M170.c M170.h M180.c M180.h M190.c M190.h M220.c M220.h M230.c M230.h M270.c M270.h
  group targets
    ../../components/targets/mcu-kit1/: hal_board.c hal_board.h hal_buzzer.c hal_buzzer.h hal_keypad.c hal_keypad.h hal_lcd.c hal_lcd.h hal_led.c hal_led.h hal_uart.c hal_uart.h
  group utilities
    ../../components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
