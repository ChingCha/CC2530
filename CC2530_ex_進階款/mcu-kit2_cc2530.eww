<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mcu-kit2\ex_basic\basic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit2\ex_keypad_lcd\keypad_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit2\ex_light_switch\light_switch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mcu-kit2\ex_uart\uart.ewp</path>
  </project>
  <batchBuild/>
</workspace>


