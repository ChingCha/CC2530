<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\keypad_lcd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


